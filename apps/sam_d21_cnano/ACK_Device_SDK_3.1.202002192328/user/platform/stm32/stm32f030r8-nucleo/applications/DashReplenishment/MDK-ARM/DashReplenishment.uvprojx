# Keil uVision project DashReplenishment.uvprojx, settings and files
target DashReplenishment (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: DashReplenishment +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../../cubemx-generated/Inc;../../cubemx-generated/Drivers/STM32F0xx_HAL_Driver/Inc;../../cubemx-generated/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../../cubemx-generated/Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../cubemx-generated/Drivers/CMSIS/Include;..\..\..\..\..\..\..\applications\DashReplenishment;..\..\..\..\..\..\..\include;..\..\..\..\..\..\..\core;..\..\..\..\..\..\..\core\generated;..\..\..\..\..\..\..\core\generated\v3avs_capabilities;..\..\..\..\..\..\..\core\generated\v3avs_types;..\..\..\..\..\..\..\external\nanopb;..;..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group ACKApplication
    ../../../../../../../applications/DashReplenishment/: DashReplenishment.c
    ../../../../: ack_stm32_ota.c ack_stm32_platform.c
    ../../../../../../: ack_user_device.c
  group ACKCore
    ../../../../../../../core/: ack_core_alexa_namespace.c ack_core_brightnesscontroller.c ack_core_circularbuffer.c ack_core_colorcontroller.c ack_core_colortemperaturecontroller.c ack_core_common.c ack_core_communication.c ack_core_cooking_common.c ack_core_cookingcontroller.c ack_core_cookingfoodtemperaturecontroller.c ack_core_cookingfoodtemperaturesensor.c ack_core_cookingpresetcontroller.c ack_core_cookingtemperaturecontroller.c ack_core_cookingtemperaturesensor.c ack_core_cookingtimecontroller.c ack_core_crc32.c ack_core_drs.c ack_core_endpointhealth.c ack_core_event_builder.c ack_core_factoryreset.c ack_core_heaplet.c ack_core_hostconfig.c ack_core_lifecycle.c ack_core_logging.c ack_core_math.c ack_core_metrics.c ack_core_modecontroller.c ack_core_module_pins.c ack_core_modulediagnostics.c ack_core_ota.c ack_core_outbound_events.c ack_core_percentagecontroller.c ack_core_powercontroller.c ack_core_processevent.c ack_core_protobuf_utilities.c ack_core_rangecontroller.c ack_core_status.c ack_core_tick64.c ack_core_timeholdcontroller.c ack_core_togglecontroller.c ack_core_userguidedsetup.c ack_core_validation.c
  group ACKCoreGenerated
    ../../../../../../../core/generated/v3avs_capabilities/: V3AVS.pb.c V3Alexa.pb.c V3AlexaBrightnessController.pb.c V3AlexaColorController.pb.c V3AlexaColorTemperatureController.pb.c V3AlexaCooking.pb.c V3AlexaCookingFoodTemperatureController.pb.c V3AlexaCookingFoodTemperatureSensor.pb.c V3AlexaCookingPresetController.pb.c V3AlexaCookingTemperatureController.pb.c V3AlexaCookingTemperatureSensor.pb.c V3AlexaCookingTimeController.pb.c V3AlexaEndpointHealth.pb.c V3AlexaInventoryLevelSensor.pb.c V3AlexaInventoryLevelUsageSensor.pb.c V3AlexaInventoryUsageSensor.pb.c V3AlexaModeController.pb.c V3AlexaPercentageController.pb.c V3AlexaPowerController.pb.c V3AlexaRangeController.pb.c V3AlexaTimeHoldController.pb.c V3AlexaToggleController.pb.c
    ../../../../../../../core/generated/v3avs_types/: V3Brightness.pb.c V3BrightnessDelta.pb.c V3Color.pb.c V3ColorTemperatureInKelvin.pb.c V3Connectivity.pb.c V3CookingMode.pb.c V3Count.pb.c V3DateTime.pb.c V3DeviceState.pb.c V3Duration.pb.c V3EnumeratedPowerLevel.pb.c V3FoodItem.pb.c V3IntegralPowerLevel.pb.c V3InventoryConsumed.pb.c V3InventoryCount.pb.c V3InventoryReplaced.pb.c V3ItemQuantity.pb.c V3Length.pb.c V3Level.pb.c V3Mode.pb.c V3ModeDelta.pb.c V3Percentage.pb.c V3PercentageDelta.pb.c V3PowerState.pb.c V3PresetName.pb.c V3Range.pb.c V3RangeDelta.pb.c V3RequiredInteraction.pb.c V3Temperature.pb.c V3TimeInterval.pb.c V3ToggleState.pb.c V3Volume.pb.c V3Weight.pb.c
    ../../../../../../../core/generated/: acp.pb.c
  group ACKExternalNanoPB
    ../../../../../../../external/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Application/User
    ../../cubemx-generated/Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/MDK-ARM
    ../../cubemx-generated/MDK-ARM/: startup_stm32f030x8.s
  group Drivers/STM32F0xx_HAL_Driver
    ../../cubemx-generated/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../cubemx-generated/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
